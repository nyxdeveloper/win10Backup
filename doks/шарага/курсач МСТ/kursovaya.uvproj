# Keil uVision project kursovaya.uvproj, settings and files
target C51 (MCS-51)
  device: ADuC842 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(32768) DPX MODAB2
  output: kursovaya +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_AD.A51 prog.c
